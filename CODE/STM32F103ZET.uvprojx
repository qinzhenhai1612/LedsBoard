# Keil uVision project STM32F103ZET.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CODE;.\USER;.\STM32F10X_LIB\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\STM32F103ZET.sct
  group CODE
    ./CODE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10X_LIB
    ./STM32F10X_LIB/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
